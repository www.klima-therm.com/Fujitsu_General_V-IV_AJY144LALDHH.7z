Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-03-30T17:26:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - 代替 UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 30 17:26:05 2022 * Host: N174135 * Database: C:\Users\nohara\AppData\Local\Temp\{2573822E-8AA6-4A5C-9A70-E6AB65A7E494}\ifc * Database version: 5507 * Database creation date: Wed Mar 30 17:26:04 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 30 17:26:04 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 30 17:26:04 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, レベル 1
LongName: レベル 1; Elevation: 0 mm

# IfcBuildingElementProxy: AJY144LALDHH, HVAC_Air-Conditioning_Fujitsu General_V-IV AJY144LALDHH:AJY144LALDHH:9571
In: レベル 1
Type - Material: Color RGB 110-110-110, Color RGB 212-204-191, Color RGB 216-216-216, Color RGB 040-040-040
Pset_BuildingElementProxyCommon - Reference: AJY144LALDHH
Pset_ManufacturerTypeInformation - Manufacturer: FUJITSU GENERAL LIMITED
